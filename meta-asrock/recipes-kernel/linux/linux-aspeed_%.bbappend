FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_x570d4u = " \
    file://0001-Add-x570d4u-bmc.patch \
"
